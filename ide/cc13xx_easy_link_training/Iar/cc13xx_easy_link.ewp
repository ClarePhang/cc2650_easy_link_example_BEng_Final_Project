# IAR project cc13xx_easy_link.ewp, settings and files
configuration TX (ARM, debug)
  General.OGChipSelectEditMenu: CC2650F128 TexasInstruments CC2650F128
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: DEBUG; BOARD_SMARTRF06EB; MODULE_CC13XX_7X7; PER_USE_FS_OVERWRITE
  ICCARM.CCIncludePath2: ..\..\..\source\components\driverlib\cc26xx\source; ..\..\..\source\components\driverlib\cc26xx\inc; ..\..\..\source\components\driverlib\cc26xx; ..\..\..\source\components\driverlib; ..\..\..\source\components\bsp\srf06eb_cc26xx\drivers\source; ..\..\..\source\components\utils; ..\..\..\source\components\utils\cc26xx; ..\..\..\source\components\common; ..\..\..\source\components\targets\interface; ..\..\..\source\components\devices\cc26xx\radio_defs; ..\..\..\source\components\devices\cc26xx\radio_files; ..\..\..\source\components\utils\cc26xx; ..\..\..\source\libraries\cc13xx_pg1_init_lib\include; ..\..\..\source\components\devices\cc26xx\radio_files\radio_patches\phy_prop_genfsk\pg1\cc13xx; C:\Users\Lucho\Documents\EE3_Bachelor Project\Datasheets\TI CC26xx\TI_CC13-26XX\TI_CC13-26XX\CC13xx\Software\cc13xx_easy_link_rev_1_0\source\components\devices\cc26xx\radio_files\radio_patches; C:\Users\Lucho\Documents\EE3_Bachelor Project\Datasheets\TI CC26xx\TI_CC13-26XX\TI_CC13-26XX\CC13xx\Software\cc13xx_easy_link_rev_1_0\source\libraries\cc13xx_pg1_init_lib; C:\Users\Lucho\Documents\EE3_Bachelor Project\Datasheets\TI CC26xx\TI_CC13-26XX\TI_CC13-26XX\CC13xx\Software\cc13xx_easy_link_rev_1_0\source\libraries\cc13xx_pg1_init_lib\include\synth_fix
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: cc13xx_per_test.bin
  ILINK.IlinkOutputFile: per_test.out
  ILINK.IlinkIcfFile: C:\Users\Lucho\Documents\EE3_Bachelor Project\Datasheets\TI_CC26xx_Final\cc26xxware\cc26xxware_2_20_06_14829\linker_files\cc26x0f128.icf
  ILINK.IlinkAdditionalLibs: ..\..\..\source\libraries\cc13xx_pg1_init_lib\binary\cc13xx_init_lib.lib
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration RX (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: CC26xx TexasInstruments CC2650F128
  ICCARM.CCIncludePath2: ..\..\..\source\components\driverlib\cc26xx\source; ..\..\..\source\components\driverlib\cc26xx\inc; ..\..\..\source\components\bsp\srf06eb_cc26xx\drivers\source; ..\..\..\source\components\utils; ..\..\..\source\components\utils\cc26xx; ..\..\..\source\components\common; ..\..\..\source\components\targets\interface; ..\..\..\source\components\devices\cc26xx\radio_defs; ..\..\..\source\libraries\cc13xx_pg1_init_lib\include; ..\..\..\source\components\devices\cc26xx\radio_files\radio_patches\phy_prop_genfsk\pg1\cc13xx
  ICCARM.CCOptStrategy: 0
  group (top)
    ../../../source/components/utils/cc26xx/: backdoor.c
    ../../../source/apps/cc13xx_easy_link_training/: cc13xx_easy_link_rx.c cc13xx_easy_link_tx.c
    ../../../source/libraries/cc13xx_pg1_init_lib/: cc13xx_pg1_init_lib.c
  group driverlib
    ../../../source/components/driverlib/cc26xx/source/: adi.c aon_batmon.c aon_event.c aon_ioc.c aon_rtc.c aon_wuc.c aux_ctrl.c aux_smph.c aux_tdc.c aux_timer.c aux_wuc.c cpu.c crypto.c ddi.c debug.c event.c flash.c gpio.c i2c.c i2s.c interrupt.c ioc.c osc.c prcm.c pwr_ctrl.c smph.c spis.c ssi.c sys_ctrl.c systick.c timer.c trng.c uart.c udma.c vims.c watchdog.c
  group driverlib/pg2
    ../../../source/components/driverlib/cc26xx/source/pg2/: chipinfo.c chipinfo.h hw_ddi.h
  group internal
    ../../../source/components/devices/cc26xx/startup_files_pg1/: setup.c startup_iar.c
  group internal/pg2
    ../../../source/components/devices/cc26xx/startup_files_pg2/: ccfg.c setup.c startup_iar.c
